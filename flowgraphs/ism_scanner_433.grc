options:
  parameters:
    author: sigint-field-kit
    comment: |-
      ISM band scanner centered on 433.92 MHz.
      Displays waterfall and FFT for passive monitoring of
      weather stations, sensors, and LoRa devices.
      Requires RTL-SDR dongle.
    copyright: Unlicense
    description: ISM 433 MHz passive scanner with waterfall display
    generate_options: qt_gui
    id: ism_scanner
    output_language: python
    title: ISM Band Scanner (433 MHz)
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: Center Freq (MHz)
    start: '420'
    step: '0.01'
    stop: '450'
    value: '433.92'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: RF Gain
    min_len: '100'
    start: '0'
    step: '1'
    stop: '49'
    value: '40'
  states: {}
- name: rtlsdr_source
  id: osmosdr_source
  parameters:
    args: ''
    sample_rate: samp_rate
    freq0: center_freq * 1e6
    gain0: rf_gain
    if_gain0: '20'
    bb_gain0: '20'
    type: fc32
  states: {}
- name: qt_gui_waterfall
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq * 1e6
    fftsize: '2048'
    gui_hint: 1,0,1,3
    int_min: '-120'
    name: '"ISM 433 Waterfall"'
    type: complex
    update_time: '0.05'
    grid: 'True'
  states: {}
- name: qt_gui_freq
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq * 1e6
    fftsize: '2048'
    gui_hint: 2,0,1,3
    name: '"ISM 433 Spectrum"'
    type: complex
    update_time: '0.05'
    ymin: '-120'
    grid: 'True'
  states: {}

connections:
- [rtlsdr_source, '0', qt_gui_waterfall, '0']
- [rtlsdr_source, '0', qt_gui_freq, '0']

metadata:
  file_format: 1
  grc_version: 3.10.0.0
