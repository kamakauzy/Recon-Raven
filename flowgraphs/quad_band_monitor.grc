options:
  parameters:
    author: sigint-field-kit
    comment: |-
      Four-band simultaneous monitor: VHF voice (146 MHz),
      ISM sensors (433.92 MHz), UHF FRS/GMRS (462 MHz),
      LoRa/Meshtastic (915 MHz). Four waterfalls + FFTs
      stacked vertically for one-glance situational awareness.
      Requires 4 RTL-SDR dongles (one per band) OR run
      sequentially with band switching.
      For single-dongle use: set unused sources to disabled
      and use the active band slider.
    copyright: Unlicense
    description: Quad-band tactical SIGINT monitor
    generate_options: qt_gui
    id: quad_band_monitor
    output_language: python
    title: Quad-Band Tactical Monitor
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: gain_all
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: RF Gain (all bands)
    min_len: '100'
    start: '0'
    step: '1'
    stop: '49'
    value: '38'
  states: {}
- name: freq_vhf
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: VHF (MHz)
    min_len: '100'
    start: '140'
    step: '0.005'
    stop: '174'
    value: '146.52'
  states: {}
- name: src_vhf
  id: osmosdr_source
  parameters:
    args: '"rtl=0"'
    sample_rate: samp_rate
    freq0: freq_vhf * 1e6
    gain0: gain_all
    if_gain0: '20'
    bb_gain0: '20'
    type: fc32
  states: {}
- name: wf_vhf
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq_vhf * 1e6
    fftsize: '1024'
    gui_hint: 1,0,1,2
    int_min: '-120'
    name: '"VHF 146 MHz"'
    type: complex
    grid: 'True'
  states: {}
- name: fft_vhf
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq_vhf * 1e6
    fftsize: '1024'
    gui_hint: 1,2,1,2
    name: '"VHF Spectrum"'
    type: complex
    ymin: '-120'
    legend: 'False'
    grid: 'True'
  states: {}
- name: freq_ism
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: ISM (MHz)
    min_len: '100'
    start: '420'
    step: '0.01'
    stop: '450'
    value: '433.92'
  states: {}
- name: src_ism
  id: osmosdr_source
  parameters:
    args: '"rtl=1"'
    sample_rate: samp_rate
    freq0: freq_ism * 1e6
    gain0: gain_all
    if_gain0: '20'
    bb_gain0: '20'
    type: fc32
  states: {}
- name: wf_ism
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq_ism * 1e6
    fftsize: '1024'
    gui_hint: 2,0,1,2
    int_min: '-120'
    name: '"ISM 433 MHz"'
    type: complex
    grid: 'True'
  states: {}
- name: fft_ism
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq_ism * 1e6
    fftsize: '1024'
    gui_hint: 2,2,1,2
    name: '"ISM Spectrum"'
    type: complex
    ymin: '-120'
    legend: 'False'
    grid: 'True'
    color1: '"green"'
  states: {}
- name: freq_uhf
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3,1,1
    label: UHF (MHz)
    min_len: '100'
    start: '450'
    step: '0.00625'
    stop: '470'
    value: '462.5625'
  states: {}
- name: src_uhf
  id: osmosdr_source
  parameters:
    args: '"rtl=2"'
    sample_rate: samp_rate
    freq0: freq_uhf * 1e6
    gain0: gain_all
    if_gain0: '20'
    bb_gain0: '20'
    type: fc32
  states: {}
- name: wf_uhf
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq_uhf * 1e6
    fftsize: '1024'
    gui_hint: 3,0,1,2
    int_min: '-120'
    name: '"UHF 462 MHz"'
    type: complex
    grid: 'True'
  states: {}
- name: fft_uhf
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq_uhf * 1e6
    fftsize: '1024'
    gui_hint: 3,2,1,2
    name: '"UHF Spectrum"'
    type: complex
    ymin: '-120'
    legend: 'False'
    grid: 'True'
    color1: '"red"'
  states: {}
- name: freq_lora
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,0,1,1
    label: LoRa (MHz)
    min_len: '100'
    start: '900'
    step: '0.1'
    stop: '930'
    value: '915'
  states: {}
- name: src_lora
  id: osmosdr_source
  parameters:
    args: '"rtl=3"'
    sample_rate: samp_rate
    freq0: freq_lora * 1e6
    gain0: gain_all
    if_gain0: '20'
    bb_gain0: '20'
    type: fc32
  states: {}
- name: wf_lora
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq_lora * 1e6
    fftsize: '1024'
    gui_hint: 4,0,1,2
    int_min: '-120'
    name: '"LoRa 915 MHz"'
    type: complex
    grid: 'True'
  states: {}
- name: fft_lora
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq_lora * 1e6
    fftsize: '1024'
    gui_hint: 4,2,1,2
    name: '"LoRa Spectrum"'
    type: complex
    ymin: '-120'
    legend: 'False'
    grid: 'True'
    color1: '"magenta"'
  states: {}

connections:
- [src_vhf, '0', wf_vhf, '0']
- [src_vhf, '0', fft_vhf, '0']
- [src_ism, '0', wf_ism, '0']
- [src_ism, '0', fft_ism, '0']
- [src_uhf, '0', wf_uhf, '0']
- [src_uhf, '0', fft_uhf, '0']
- [src_lora, '0', wf_lora, '0']
- [src_lora, '0', fft_lora, '0']

metadata:
  file_format: 1
  grc_version: 3.10.0.0
