options:
  parameters:
    author: sigint-field-kit
    comment: |-
      LoRa / ISM 915 MHz band watcher.
      Passive waterfall and spectrum display for
      monitoring Meshtastic, LoRa, and IoT devices.
      Requires RTL-SDR dongle.
    copyright: Unlicense
    description: 915 MHz LoRa / ISM band passive monitor
    generate_options: qt_gui
    id: lora_watcher
    output_language: python
    title: LoRa / ISM 915 MHz Watcher
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: Center Freq (MHz)
    start: '900'
    step: '0.1'
    stop: '930'
    value: '915'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: RF Gain
    min_len: '100'
    start: '0'
    step: '1'
    stop: '49'
    value: '40'
  states: {}
- name: rtlsdr_source
  id: osmosdr_source
  parameters:
    args: ''
    sample_rate: samp_rate
    freq0: center_freq * 1e6
    gain0: rf_gain
    if_gain0: '20'
    bb_gain0: '20'
    type: fc32
  states: {}
- name: qt_gui_waterfall
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq * 1e6
    fftsize: '2048'
    gui_hint: 1,0,1,3
    int_min: '-120'
    name: '"LoRa 915 Waterfall"'
    type: complex
    update_time: '0.05'
    grid: 'True'
  states: {}
- name: qt_gui_freq
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq * 1e6
    fftsize: '2048'
    gui_hint: 2,0,1,3
    name: '"LoRa 915 Spectrum"'
    type: complex
    update_time: '0.05'
    ymin: '-120'
    grid: 'True'
  states: {}

connections:
- [rtlsdr_source, '0', qt_gui_waterfall, '0']
- [rtlsdr_source, '0', qt_gui_freq, '0']

metadata:
  file_format: 1
  grc_version: 3.10.0.0
