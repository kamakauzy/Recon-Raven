options:
  parameters:
    author: sigint-field-kit
    comment: |-
      NBFM channel scanner for FRS, GMRS, MURS, and common
      Baofeng frequencies. Stops on active channels when
      signal exceeds squelch threshold. Audio output + waterfall.
      Single RTL-SDR dongle — wide enough BW to cover
      FRS/GMRS simultaneously (462-467 MHz).
      Requires: RTL-SDR, audio output device.
    copyright: Unlicense
    description: NBFM channel scanner for FRS/GMRS/MURS voice monitoring
    generate_options: qt_gui
    id: nbfm_scanner
    output_language: python
    title: NBFM Voice Channel Scanner
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: channel_freq
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,1,2
    label: Channel
    label0: FRS 1 (462.5625)
    label1: FRS 2 (462.5875)
    label2: FRS 3 (462.6125)
    label3: FRS 4 (462.6375)
    label4: FRS 5 (462.6625)
    label5: FRS 6 (462.6875)
    label6: FRS 7 (462.7125)
    label7: FRS 8 (467.5625)
    label8: GMRS 15 (462.550)
    label9: GMRS 16 (462.575)
    num_opts: '10'
    option0: '462562500'
    option1: '462587500'
    option2: '462612500'
    option3: '462637500'
    option4: '462662500'
    option5: '462687500'
    option6: '462712500'
    option7: '467562500'
    option8: '462550000'
    option9: '462575000'
    type: int
    value: '462562500'
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: Center of FRS/GMRS band — single dongle covers all channels
    value: '465000000'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: RF Gain
    min_len: '100'
    start: '0'
    step: '1'
    stop: '49'
    value: '38'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3,1,1
    label: Volume
    min_len: '100'
    start: '0'
    step: '0.05'
    stop: '2.0'
    value: '0.7'
  states: {}
- name: squelch_level
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,0,1,2
    label: Squelch (dB)
    start: '-100'
    step: '1'
    stop: '0'
    value: '-50'
  states: {}
- name: rtlsdr_source
  id: osmosdr_source
  parameters:
    args: ''
    sample_rate: samp_rate
    freq0: center_freq
    gain0: rf_gain
    if_gain0: '20'
    bb_gain0: '20'
    type: fc32
  states: {}
- name: freq_xlat
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: channel_freq - center_freq
    comment: Shift selected channel to baseband
    decim: int(samp_rate / 48000)
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 6250, 1000)
    type: ccc
  states: {}
- name: pwr_squelch
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'False'
    ramp: '0'
    threshold: squelch_level
    type: complex
  states: {}
- name: nbfm_demod
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: '5000'
    quad_rate: '48000'
    tau: '75e-6'
  states: {}
- name: vol_multiply
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: audio_sink
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: wf_wide
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '2048'
    gui_hint: 1,0,1,4
    int_max: '0'
    int_min: '-100'
    name: '"FRS/GMRS Band Overview"'
    type: complex
    update_time: '0.05'
    grid: 'True'
  states: {}
- name: fft_wide
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '2048'
    gui_hint: 2,0,1,4
    name: '"FRS/GMRS Spectrum"'
    type: complex
    update_time: '0.05'
    ymin: '-100'
    ymax: '0'
    grid: 'True'
  states: {}
- name: audio_scope
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 3,0,1,4
    label1: Audio
    name: '"Demodulated Audio"'
    size: '48000'
    srate: '48000'
    type: float
  states: {}

connections:
- [rtlsdr_source, '0', freq_xlat, '0']
- [rtlsdr_source, '0', wf_wide, '0']
- [rtlsdr_source, '0', fft_wide, '0']
- [freq_xlat, '0', pwr_squelch, '0']
- [pwr_squelch, '0', nbfm_demod, '0']
- [nbfm_demod, '0', vol_multiply, '0']
- [vol_multiply, '0', audio_sink, '0']
- [vol_multiply, '0', audio_scope, '0']

metadata:
  file_format: 1
  grc_version: 3.10.0.0
