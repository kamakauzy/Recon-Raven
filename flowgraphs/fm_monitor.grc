options:
  parameters:
    author: sigint-field-kit
    comment: |-
      Wideband FM receiver for monitoring local voice comms.
      Tune freq_mhz to target (default 146.52 MHz).
      Requires RTL-SDR dongle.
    copyright: Unlicense
    description: Wideband FM monitor with audio output
    generate_options: qt_gui
    id: fm_monitor
    output_language: python
    title: FM Voice Monitor
  states: {}

blocks:
- name: freq_mhz
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: Frequency (MHz)
    start: '80'
    step: '0.005'
    stop: '500'
    value: '146.52'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: Volume
    min_len: '100'
    start: '0'
    step: '0.05'
    stop: '1'
    value: '0.5'
  states: {}
- name: rtlsdr_source
  id: osmosdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    freq0: freq_mhz * 1e6
    gain0: '40'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: low_pass_filter
  id: low_pass_filter
  parameters:
    cutoff_freq: '100000'
    decim: int(samp_rate / 480000)
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '10000'
    win: window.WIN_HAMMING
  states: {}
- name: wfm_demod
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: '480000'
  states: {}
- name: audio_multiply
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: audio_sink
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: qt_gui_waterfall
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq_mhz * 1e6
    fftsize: '1024'
    gui_hint: 1,0,1,3
    type: complex
  states: {}
- name: qt_gui_freq
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq_mhz * 1e6
    fftsize: '1024'
    gui_hint: 2,0,1,3
    type: complex
  states: {}

connections:
- [rtlsdr_source, '0', low_pass_filter, '0']
- [rtlsdr_source, '0', qt_gui_waterfall, '0']
- [rtlsdr_source, '0', qt_gui_freq, '0']
- [low_pass_filter, '0', wfm_demod, '0']
- [wfm_demod, '0', audio_multiply, '0']
- [audio_multiply, '0', audio_sink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.0.0
